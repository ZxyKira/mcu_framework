# Keil uVision project framework.uvprojx, settings and files
target framework (6120000::V6.12::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: framework
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\code\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group include
    ../include/: fw_base.h fw_io_pin.h fw_io.h fw_spim.h fw_timer.h fw_usart.h fw_ioint.h fw_i2c.h
